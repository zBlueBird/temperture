# Keil uVision project temp-master.uvprojx, settings and files
target voice-master (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\mcu\module\data_uart_cmd;..\..\..\src\app\vocie_master\data_uart;..\ble_central;..\..\..\src\ble\profile\client;..\..\..\src\app\vocie_master\audio_module;..\..\..\src\app\vocie_master\key_module;..\..\..\src\app\vocie_master\auto_test;..\..\..\src\app\vocie_master\voice_module;..\..\..\src\app\vocie_master\led_module;..\..\..\src\app\vocie_master;..\voice_master;..\..\..\src\app\vocie_master\vs1053b
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../bin/: ROM.lib gap_utils.lib sbc_lib_o3.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_rcc.c rtl876x_uart.c rtl876x_i2s.c rtl876x_gdma.c rtl876x_gpio.c rtl876x_codec.c rtl876x_i2c.c rtl876x_keyscan.c
  group profile
    ../../../src/ble/profile/client/: bas_client.c gaps_client.c voice_client.c
  group app
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../src/app/vocie_master/: central_app.c link_mgr.c main.c app_task.c
  group auto_test
    ../../../src/app/vocie_master/auto_test/: auto_test.c
  group voice
    ../../../src/app/vocie_master/voice_module/: voice_s2m.c
  group led
    ../../../src/app/vocie_master/led_module/: led_driver.c
  group data_uart
    ../../../src/app/vocie_master/data_uart/: data_uart_test.c uart_transport.c user_cmd.c
